# Keil uVision project UKU20204L.uvproj, settings and files
target MK (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKU20204_MK_WEB +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=900, WG12232A
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTTP
    ./Web/: web.inp
  group Startup
    ./: startup_LPC17xx.s Net_Config.c Net_Config_HTTP.c
  group Core Code
    ./: core_cm3.c
  group System Code
    ./: system_LPC17xx.c timer.c
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
    C:/Keil/ARM/Boards/Keil/MCB1700/RL/TCPnet/Library/: EMAC_LPC17xx.c
    ./: 25lc640.c lcd_agm1232_uku203.c simbols.c ret.c beep.c common_func.c gran.c graphic.c cmd.c
  group Sources
    ./: main.c avar.c control.c eeprom_map.c memo.c SNMP_MIB.c snmp_data_file.c HTTP_CGI.c curr_version.c
    ./Web/: Web.c
  group Interfaces
    ./: uart0.c full_can.c
  group Connecting
    ./: http_data.c sntp.c
target MK24 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MK_24_WEB +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=900, _24_
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target RECOVERY (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKU20204_WEB_RECOVERY +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=900, WEB_RECOVERY
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK-без-Eth-1765 (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MK_ETH_OFF_1765 +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=900, LAN_OFF
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target МС (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MС_WEB +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=300, NEW_MOSKOW_BPS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK_WG12232L3 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MK_WEB_WG12232L3 +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=900, WG12232L3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MC_WG12232L3 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MC_WEB_WG12232L3 +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=300, WG12232L3, NEW_MOSKOW_BPS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK-без-Eth-1765_WG12232L3 (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MK_ETH_OFF_1765_WG12232L3 +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=900, LAN_OFF, WG12232L3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MC-без-Eth-1765_WG12232L3 (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MC_ETH_OFF_1765_WG12232L3 +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=300, LAN_OFF, WG12232L3, NEW_MOSKOW_BPS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK_24_WG12232L3 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_24_MK_WEB_WG12232L3 +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=900, WG12232L3, _24_
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MC_24_WG12232L3 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_24_MC_WEB_WG12232L3 +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=300, WG12232L3, _24_, NEW_MOSKOW_BPS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK_24-без-Eth-1765_WG12232L3 (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_24_MK_ETH_OFF_1765_WG12232L3 +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=900, LAN_OFF, WG12232L3, _24_
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MC_24-без-Eth-1765_WG12232L3 (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_24_MC_ETH_OFF_1765_WG12232L3 +hex
  BeforeMake: python curr_version.py
  c flags: Optim=4
  c define: UKU_VERSION=300, LAN_OFF, WG12232L3, _24_, NEW_MOSKOW_BPS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
